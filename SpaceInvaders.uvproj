# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s SpaceInvaders.c TExaS.c VirtualNokia5110.c Sound.c
    ../Lab14_VirtualMeasurementOfDistance/: ADC.c
    ../Lab13_DAC - WorkingSolution/: DAC.c DAC.h
